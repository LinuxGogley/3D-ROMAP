# Keil uVision project LiDAR_Launchpad.uvproj, settings and files
target LiDAR_LauchPad (ARM-ADS)
  device: LM4F120H5QR Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(8000000) CPUTYPE("Cortex-M4") FPU2
  output: LiDAR LaunchPad
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: rvmdk PART_LM4F120H5QR
  c include: ..;..\..\..
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source
    ./: startup.s I2C_init.c main.c UART.c
    ./driverlib/: i2c.c sysctl.c gpio.c interrupt.c cpu.c
